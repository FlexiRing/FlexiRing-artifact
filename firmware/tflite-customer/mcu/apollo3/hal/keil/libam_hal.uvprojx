# Keil uVision project libam_hal.uvprojx, settings and files
target libam_hal (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: AMA3B1KK-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.4.1
  cpu: IROM(0x00000000,0x100000) IRAM(0x10000000,0x60000) CPUTYPE("Cortex-M4") FPU2 CLOCK(48000000) ELITTLE
  output: libam_hal (library)
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AM_PART_APOLLO3 AM_ASSERT_INVALID_THRESHOLD=0 AM_DEBUG_ASSERT keil
  c include: ../../../../CMSIS/ARM/Include;../../../../CMSIS/AmbiqMicro/Include;../../../../mcu/apollo3
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x60000
  group source_files
    ../: am_hal_adc.c am_hal_ble.c am_hal_ble_patch.c am_hal_ble_patch_b0.c am_hal_burst.c am_hal_cachectrl.c am_hal_clkgen.c am_hal_cmdq.c am_hal_ctimer.c am_hal_debug.c am_hal_entropy.c am_hal_flash.c am_hal_global.c am_hal_gpio.c am_hal_interrupt.c am_hal_iom.c am_hal_ios.c am_hal_itm.c am_hal_mcuctrl.c am_hal_mspi.c am_hal_pdm.c am_hal_pwrctrl.c am_hal_queue.c am_hal_reset.c am_hal_rtc.c am_hal_scard.c am_hal_secure_ota.c am_hal_security.c am_hal_stimer.c am_hal_sysctrl.c am_hal_systick.c am_hal_tpiu.c am_hal_uart.c am_hal_wdt.c
