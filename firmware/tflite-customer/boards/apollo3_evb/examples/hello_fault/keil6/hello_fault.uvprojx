# Keil uVision project hello_fault.uvprojx, settings and files
target hello_fault (6160000::V6.16::ARMCLANG)
  device: AMA3B1KK-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.5.4
  cpu: IRAM(0x10000000,0x00060000) IROM(0x0000C000,0x000F4000) CPUTYPE("Cortex-M4") FPU2 CLOCK(48000000) ELITTLE
  output: hello_fault
  AfterMake: fromelf --bin --output bin\hello_fault.bin bin\hello_fault.axf
  AfterMake: fromelf -cedrst --output bin\hello_fault.txt bin\hello_fault.axf
  c flags: Optim=3 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=8 wLevel=3
  c define: AM_PART_APOLLO3 AM_UTIL_FAULTISR_PRINT AM_PACKAGE_BGA keil6 __STDINT_NO_EXPORTS ARM_MATH_CM4 __FPU_PRESENT=1
  c misc: -fno-exceptions -mno-unaligned-access
  c include: ../../../../../utils;../../../../..;../../../../../devices;../../../bsp;../../../../../mcu/apollo3;../../../../../CMSIS/ARM/Include;../src;../../../../../CMSIS/AmbiqMicro/Include;..\..\..\..\..\mcu\apollo3\hal;..\keil6
  memory RVCT4: ROM 0xc000 size 0xf4000
  memory RVCT9: RAM 0x10000000 size 0x60000
  scatter file: .\hello_fault.sct
  link misc: ../../../../../mcu/apollo3/hal/keil6/bin/libam_hal.lib(am_hal_global.o) --keep=am_hal_global.o(.data) --undefined=__scatterload_copy
  group src
    ./: retarget.c gesture.cpp uart_print.h uart_print.c classifier.c classifier.h prototypes.c
    ../src/: hello_fault.cpp gesture_input_data.cpp gesture_input_data.h
  group utils
    ../../../../../utils/: am_util_delay.c am_util_faultisr.c am_util_stdio.c am_util_debug.c am_util_id.c
  group keil6
    ../keil6/: startup_keil6.s
  group lib
    ../../../../../mcu/apollo3/hal/keil6/bin/: libam_hal.lib
    ../../../bsp/keil6/bin/: libam_bsp.lib
  group devices
    ../../../../../devices/: am_devices_led.c am_devices_button.c
  group model
    ../src/: gesture_model_quantized.cpp gesture_model_quantized.h gesture_model.cpp
    ./: gesture_model.h
software components: CMSIS:NN Lib 7.0.0, Data Exchange:Serialization:flatbuffers 1.25.2, Data Processing:Math:gemmlowp fixed-point 1.25.2, Data Processing:Math:kissfft 1.25.2, Data Processing:Math:ruy 1.25.2, Machine Learning:TensorFlow:Kernel Utils 1.25.2, Machine Learning:TensorFlow:Kernel 1.25.2
